# Keil uVision project RadioToSerial.uvproj, settings and files
target Simulator_315 (MCS-51)
  device: eo3000i EnOcean
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0-0x7FF) CLOCK(16000000)
  output: RadioToSerial_315 +hex
  AfterMake: eopx.exe -fprg "#H" -fcfg "$H@H_cfg.hex" -script "$Ppostbuild.txt"
  c flags: Optimize=9 SizeSpeed=1
  c define: RELEASE
  group Application
    ./: main.c STARTUP.A51 postbuild.txt
  group EO3000I_API
    ./: EO3000I_CFG.h EO3000I_CFG.c tcm320-868mhz-4dbm-1v51-da.a51 EO3000I_API.h EO3000I_API.LIB EO3000I_API_FSK.LIB
target Simulator_868 (MCS-51)
  device: eo3000i EnOcean
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0-0x7FF) CLOCK(16000000)
  output: RadioToSerial_868 +hex
  AfterMake: as above
  c flags: Optimize=9 SizeSpeed=1
  c define: RELEASE
target Simulator_902 (MCS-51)
  device: eo3000i EnOcean
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) XRAM (0-0x7FF) CLOCK(16000000)
  output: RadioToSerial_902 +hex
  AfterMake: as above
  c flags: Optimize=9 SizeSpeed=1
  c define: RELEASE
